# IAR project example_mti1_i2c_spi_receive_measurement_data.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.PreInclude: preinclude.h
  ICCARM.CCIncludePath2: ..\src; ..\..\lib; ..\..\lib\mtinterface; ..\..\lib\xbus; ..\..\lib\setup; ..\..\lib\drivers\CMSIS\Include; ..\..\lib\drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\lib\drivers\STM32F4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: example_mti1_i2c_spi_receive_measurement_data.bin
  ILINK.IlinkOutputFile: example_mti1_i2c_spi_receive_measurement_data.out
  ILINK.IlinkIcfFile: stm32f401xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../lib/: board.h fifobuffer.cpp hostinterface.cpp init_gpio.cpp init_i2c.cpp init_spi.cpp init_uart.cpp runtimeerror.cpp system_clock_config.cpp systick.cpp wait.cpp
  group lib/drivers/STM32F4xx_HAL_Driver
    ../../lib/drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group lib/mtinterface
    ../../lib/mtinterface/: mtssp_driver_i2c.cpp mtssp_driver_spi.cpp mtssp_interface.cpp
  group lib/setup
    ../../lib/setup/: startup_stm32f401xe.s system_stm32f4xx.c
  group lib/xbus
    ../../lib/xbus/: xbushelpers.cpp xbusmessage.c
  group src
    ../src/: application.cpp main.cpp preinclude.h xbustostring.cpp
